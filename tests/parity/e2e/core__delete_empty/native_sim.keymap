/* GENERATED by tests/parity/e2e/generate.sh — do not edit. */
/* Parity: same input as tests/core/delete_empty, new stack, same snapshot. */
#include "../../../core/delete_empty/native_sim.keymap"
