/* GENERATED by tests/parity/e2e/generate.sh — do not edit. */
/* Parity: same input as tests/core/delete_reuse, new stack, same snapshot. */
#include "../../../core/delete_reuse/native_sim.keymap"
